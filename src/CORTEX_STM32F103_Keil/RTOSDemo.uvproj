# Keil uVision project RTOSDemo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: bc_center +hex
  c flags: Optim=4
  c define: RVDS_ARMCM3_LM3S102
  c include: ..\CORTEX_STM32F103_Keil;.\STM32F10xFWLib\inc;.\bc_src\main\inc;.\bc_src\bluetooth\inc;.\bc_src\datahub\inc;.\bc_src\net_server\inc;.\bc_src\phone_app\inc;.\bc_src\other\irq;.\bc_src\other\public;.\bc_src\other\config;.\bc_src\freertos_src\include;.\bc_src\freertos_src\portable\RVDS\ARM_CM3;.\bc_src\zigbee\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STM32 LIB
    ./STM32F10xFWLib/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_systick.c stm32f10x_tim.c cortexm3_macro_rvds.s
  group main
    ./bc_src/main/src/: main.c
  group other
    ./bc_src/other/irq/: STM32F10x.s irq.c
    ./bc_src/other/config/: bc_init.c
    ./bc_src/other/public/: terminal.c
  group zigbee
    ./bc_src/zigbee/src/: zigbee_agent_task.c
  group bluetooth
    ./bc_src/bluetooth/src/: bt_ui_task.c
  group phone_app
    ./bc_src/phone_app/src/: app_agent_common.c app_agent_irq.c app_agent_task.c
  group net_server
    ./bc_src/net_server/src/: server_agent_task.c
  group datahub
    ./bc_src/datahub/src/: datahub_task.c
  group freertos
    ./bc_src/freertos_src/: list.c queue.c tasks.c
    ./bc_src/freertos_src/portable/RVDS/ARM_CM3/: port.c
    ./bc_src/freertos_src/portable/MemMang/: heap_2.c
